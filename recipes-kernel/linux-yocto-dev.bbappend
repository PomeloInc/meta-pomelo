KBRANCH_beaglebone-yocto = "standard/beaglebone"

KMACHINE_beaglebone-yocto ?= "beaglebone"

COMPATIBLE_MACHINE_beaglebone-yocto = "beaglebone-yocto"
