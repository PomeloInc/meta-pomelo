KBRANCH_beaglebone-yocto = "v5.4/standard/beaglebone"
KBRANCH_beaglebone_pomelo = "v5.4/standard/beaglebone"
KBRANCH_beaglebone_pomelo-flasher = "v5.4/standard/beaglebone"

KMACHINE_beaglebone_pomelo = "beaglebone-pomelo"
KMACHINE_beaglebone_pomelo-flasher = "beaglebone-pomelo-flasher"

SRCREV_machine_pomelo-minimal ?= "706efec4c1e270ec5dda92275898cd465dfdc7dd"
SRCREV_machine_pomelo-flasher ?= "706efec4c1e270ec5dda92275898cd465dfdc7dd"

COMPATIBLE_MACHINE_beaglebone_pomelo = "beaglebone-pomelo"
COMPATIBLE_MACHINE_beaglebone_pomelo-flasher = "beaglebone-pomelo-flasher"

LINUX_VERSION_beaglebone_pomelo-minimal = "5.4.58"
LINUX_VERSION_beaglebone_pomelo-flasher = "5.4.58"